# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  c flags: Optim=1
  c include: C:\Keil\ARM\RV31\LIB\Luminary\driverlib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s main.c keypad_funcs.c delay_funcs.c Beef.c Chicken.c Popcorn.c custom_cooking.c scan_with_clear.c LEDS_BUZZ.c delay_to_press.c lcd.c prototype&header.h
